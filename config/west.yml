## config/west.yml
```yaml
manifest:
  projects:
    - name: zmk
      remote: zmkfirmware
      revision: v3.5.0
```
